# Keil uVision project blinky.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1113FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: blinky
  AfterMake: fromelf --bin --output=./Objects/blinky.bin ./Objects/blinky.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: blinky.c
  group Startup
    ./Startup/: startup_LPC11xx.s system_LPC11xx.c
software components: CMSIS:CORE 5.3.0
