# Keil uVision project LPC1113_GCC_Keil_Blinky.uvprojx, settings and files
target Debug (ARM-GNU)
  device: LPC1113FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LPC1113_GCC_Keil_Blinky
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf --bin --output=LPC1113_GCC_Keil_Blinky.bin LPC1113_GCC_Keil_Blinky.elf
  group Startup
    ./Startup/: system_LPC11xx.c startup_LPC11xx.S
  group Application
    ./: blinky.c
  group CMSIS
    ./CMSIS/Include/: LPC11xx.h
