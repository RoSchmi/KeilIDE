# Keil uVision project LPC_1114F_I2C_driver.uvproj, settings and files
target LPC1114F302_Flash (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC_1114F_I2C_driver
  c flags: Optim=1
  c include: G:\Data\Code\LPC1114F_302\ServoInOut_Module\HAL;G:\Data\Code\LPC1114F_302\ServoInOut_Module\DaisyLink;G:\Data\Code\LPC1114F_302\ServoInOut_Module\Main;G:\Data\Code\LPC1114F_302\ServoInOut_Module\Common;G:\Data\Code\LPC1114F_302\ServoInOut_Module\GPIO
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./Startup/: startup_LPC11xx.s system_LPC11xx.c
  group Main
    ./Main/: User.c
  group DaisyLink
    ./DaisyLink/: DaisyLink.c DaisyLink.h
  group HAL
    ./HAL/: I2C.c I2C.h HAL_LPC1114F302.c HAL.h
  group Common
    ./Common/: type.h
  group GPIO
    ./GPIO/: gpio.c gpio.h
