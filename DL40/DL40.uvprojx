# Keil uVision project DL40.uvprojx, settings and files
target DL40_Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1113FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DL40 +hex
  AfterMake: fromelf --bin --output=DL40.bin .\Flash\DL40.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: G:\Data\Code\LPC1114F_302\DL40_Module\Main;G:\Data\Code\LPC1114F_302\DL40_Module\Common;G:\Data\Code\LPC1114F_302\DL40_Module\DaisyLink;G:\Data\Code\LPC1114F_302\DL40_Module\GPIO;G:\Data\Code\LPC1114F_302\DL40_Module\HAL;G:\Data\Code\LPC1114F_302\DL40_Module\Startup
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group DaisyLink
    ./DaisyLink/: DaisyLink.c DaisyLink.h
  group Common
    ./Common/: type.h
  group GPIO
    ./GPIO/: gpio.c gpio.h
  group HAL
    ./HAL/: HAL.h HAL_LPC1114F302.c I2C.c I2C.h
  group Main
    ./Main/: DL40.c DL40.h
  group Startup
    ./Startup/: startup_LPC11xx.s system_LPC11xx.c
software components: CMSIS:CORE 5.3.0
